# Keil uVision project test.uvproj, settings and files
target test (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: test +hex
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x00000000)
  AfterMake: fromelf --bin -o @L.bin "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: CORTEX _LPC1100_
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartUp
    ./: startup_LPC11xx.s
  group main
    ./: main.c
target canhacker11 (release) (ARM-ADS)
  device: LPC11C14/301 NXP (founded by Philips)
  cpu: as above
  output: canhacker11_rel +hex
  c flags: Optim=3 oTime=1 v6Lang=1 v6LangP=1
  c define: CORTEX _LPC1100_
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
